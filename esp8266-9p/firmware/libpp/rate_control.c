/* rate_control - clean-room implementation; see
 * rate_control.h for provenance. */
#include "rate_control.h"

#include <string.h>

uint8_t our_controls[256];

static const uint16_t our_ack_time[32] = {
	314, 258, 223, 213, 314, 162, 127, 117,
	44, 44, 48, 60, 44, 44, 48, 60,
	60, 48, 48, 44, 44, 44, 44, 44,
	60, 48, 48, 44, 44, 44, 44, 44
};

/* RC_SetBasicRate's full-mask table, reconstructed
 * byte-for-byte from its store sequence (B31). */
static const uint8_t default_controls[256] = {
	0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x01, 0x01, 0x00,
	0x2e, 0xba, 0x00, 0x00, 0x02, 0x02, 0x02, 0x00, 0x17, 0x5d, 0x00, 0x00, 0x03, 0x03, 0x03, 0x00,
	0x00, 0x04, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x05, 0x05, 0x01, 0x00,
	0x2e, 0xba, 0x00, 0x00, 0x06, 0x06, 0x02, 0x00, 0x17, 0x5d, 0x00, 0x00, 0x07, 0x07, 0x03, 0x00,
	0x55, 0x15, 0x00, 0x00, 0x09, 0x09, 0x07, 0x00, 0xaa, 0x2a, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0x55, 0x55, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00, 0xaa, 0xaa, 0x00, 0x00, 0x0b, 0x0b, 0x04, 0x00,
	0xf6, 0x12, 0x00, 0x00, 0x09, 0x09, 0x07, 0x00, 0x71, 0x1c, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0xe3, 0x38, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00, 0xc7, 0x71, 0x00, 0x00, 0x0b, 0x0b, 0x04, 0x00,
	0x89, 0x9d, 0x00, 0x00, 0x0b, 0x0b, 0x04, 0x00, 0xc4, 0x4e, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00,
	0x83, 0x34, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00, 0x62, 0x27, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0x41, 0x1a, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00, 0xb1, 0x13, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0x81, 0x11, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00, 0xc0, 0x0f, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0xc8, 0x8d, 0x00, 0x00, 0x0b, 0x0b, 0x04, 0x00, 0xe4, 0x46, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00,
	0x42, 0x2f, 0x00, 0x00, 0x0a, 0x0a, 0x05, 0x00, 0x72, 0x23, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0xa1, 0x17, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00, 0xb9, 0x11, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
	0xc0, 0x0f, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00, 0x2d, 0x0e, 0x00, 0x00, 0x09, 0x09, 0x06, 0x00,
};

static uint32_t
dur_factor(uint32_t rate)
{
	uint32_t w;
	memcpy(&w, our_controls + (rate & 0xFFu) * 8, 4);
	return w;
}

uint32_t
RC_GetAckRate(uint32_t rate)
{
	return our_controls[(rate & 0xFFu) * 8 + 5];
}

uint32_t
RC_GetRtsRate(uint32_t rate)
{
	return our_controls[(rate & 0xFFu) * 8 + 4];
}

uint16_t
RC_GetAckTime(uint32_t rate)
{
	return our_ack_time[RC_GetAckRate(rate) & 31u];
}

uint32_t
RC_GetCtsTime(uint32_t rate, uint32_t len, uint32_t extra)
{
	uint32_t r = rate & 0xFFu;
	uint32_t bits = ((len & 0xFFFFu) << 3) & 0xFFFFu;
	uint32_t preamble, sifs, dur;

	preamble = r < 5 ? 192 : r < 8 ? 96 : r < 16 ? 20 : 36;
	sifs = r < 8 ? 10 : 16;
	if (r >= 8)
		bits = (bits + 22) & 0xFFFFu;
	dur = ((bits * dur_factor(r) + 0x3FFFFu) >> 18) & 0x3FFFu;
	if (r >= 8)
		dur = (dur + 3) & ~3u;
	return (preamble + ((extra + sifs) & 0xFFFFu) + dur) & 0xFFFFu;
}

uint32_t
RC_GetBlockAckTime(uint32_t rate)
{
	uint32_t ack = RC_GetAckRate(rate);
	uint32_t preamble, mult, dur;

	if (ack < 8) {
		preamble = (ack < 5 ? 192 : 96) + 10;
		mult = 0x100;
	} else {
		preamble = (ack <= 15 ? 20 : 36) + 16;
		mult = 0x116;
	}
	dur = ((mult * dur_factor(ack) + 0x3FFFFu) >> 18) & 0x3FFFu;
	if (ack >= 8)
		dur = (dur + 3) & ~3u;
	return (preamble + dur) & 0xFFFFu;
}

int
RC_SetBasicRate(uint32_t supported_mask, int8_t erp)
{
	if ((supported_mask & 0x15Fu) == 0x15Fu) {
		memcpy(our_controls, default_controls,
		       sizeof(default_controls));
	} else {
		uint8_t b = (uint8_t)(((erp == 1) ? 4 : 0) | 1);
		uint8_t c = (uint8_t)(((erp == 1) ? 4 : 0) | 3);

		our_controls[11 * 8 + 4] = b;
		our_controls[15 * 8 + 4] = b;
		our_controls[10 * 8 + 4] = b;
		our_controls[14 * 8 + 4] = c;
		our_controls[9 * 8 + 4] = c;
		our_controls[13 * 8 + 4] = c;
		our_controls[8 * 8 + 4] = c;
		our_controls[12 * 8 + 4] = c;
	}
	return 0;
}
